# Keil uVision project freertos.uvprojx, settings and files
target FreeRTOS_uv5 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: freertos
  c flags: Optim=4
  c include: .;..;..\FreeRTOS-8.2.0\Source\portable\RVDS\ARM_CM4F;..\FreeRTOS-8.2.0;..\FreeRTOS-8.2.0\Source\include;..\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: app_config.h freertos_demo.c interrupt_routines.h interrupt_routines.c led_display.h led_display.c touch_input.h touch_input.c button_input.c button_input.h FreeRTOSConfig.h
  group FreeRTOS
    ../FreeRTOS-8.2.0/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS-8.2.0/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS-8.2.0/Source/portable/MemMang/: heap_2.c
  group Drivers
    ../drivers/: config.h dma.h dma.c gpio.h gpio.c i2c.h i2c.c interrupt.h interrupt.c spi.h spi.c timer.h timer.c uart.h uart.c
  group tasks
    ./: tasks.h blinking_eyes.c bloom.h bloom.c drawer.h drawer.c hypervisor.h hypervisor.c plot_animation.h plot_animation.c pong.h pong.c scroll.h scroll.c snake.h snake.c lookup_table.h task_bluetooth.c mario_world.h dance.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
